# IAR project PRCM.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: CC3200 TexasInstruments CC3200
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: ewarm
  ICCARM.IExtraOptions: --diag_suppress Pa050
  ICCARM.CCIncludePath2: C:\Users\erhan\github\mcu\cc3200_c_sdk\PRCM\0-sdkLayer\0.1-cc3200Sdk\driverlib; C:\Users\erhan\github\mcu\cc3200_c_sdk\PRCM\0-sdkLayer\0.1-cc3200Sdk\inc; C:\Users\erhan\github\mcu\cc3200_c_sdk\PRCM\2-midLayer; C:\Users\erhan\github\mcu\cc3200_c_sdk\PRCM\1-lowLayer; C:\Users\erhan\github\mcu\cc3200_c_sdk\PRCM\1-lowLayer\1.2-hardInterfaces
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: PRCM.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkConfigDefines: CC3200_ES_1_2_1=0
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\TexasInstruments\cc3200.icf
  ILINK.IlinkAdditionalLibs: C:\Users\erhan\github\mcu\cc3200_c_sdk\PRCM\0-sdkLayer\0.1-cc3200Sdk\driverlib\ewarm\Release\Exe\driverlib.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: main.c
  group 0-sdkLayer/0.1-cc3200Sdk/driverlib
    0-sdkLayer/0.1-cc3200Sdk/driverlib/: adc.c aes.c camera.c cpu.c crc.c debug.h des.c flash.c gpio.c hwspinlock.c i2c.c i2s.c interrupt.c pin.c prcm.c rom.h rom_map.h rom_patch.h sdhost.c shamd5.c spi.c systick.c timer.c uart.c udma.c utils.c version.h wdt.c
  group 0-sdkLayer/0.1-cc3200Sdk/inc
    0-sdkLayer/0.1-cc3200Sdk/inc/: asmdefs.h hw_adc.h hw_aes.h hw_apps_config.h hw_apps_rcm.h hw_camera.h hw_common_reg.h hw_des.h hw_dthe.h hw_flash_ctrl.h hw_gpio.h hw_gprcm.h hw_hib1p2.h hw_hib3p3.h hw_i2c.h hw_ints.h hw_mcasp.h hw_mcspi.h hw_memmap.h hw_mmchs.h hw_nvic.h hw_ocp_shared.h hw_shamd5.h hw_stack_die_ctrl.h hw_timer.h hw_types.h hw_uart.h hw_udma.h hw_wdt.h
  group 1-lowLayer
    1-lowLayer/: common.h LL_prcm.c LL_prcm.h RegisterTypes.h SystemInit.c
  group 1-lowLayer/hardInterfaces
    1-lowLayer/1.2-hardInterfaces/: button_if.c button_if.h gpio_if.c gpio_if.h i2c_if.c i2c_if.h i2s_if.c i2s_if.h systick_if.c systick_if.h timer_if.c timer_if.h uart_if.c uart_if.h utils_if.c utils_if.h wdt_if.c wdt_if.h
