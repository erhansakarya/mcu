# IAR project GPIO.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: CC3200 TexasInstruments CC3200
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: ewarm
  ICCARM.IExtraOptions: --diag_suppress Pa050
  ICCARM.CCIncludePath2: C:\Users\erhan\github\mcu\cc3200_c_pure\GPIO\0-sdkLayer\inc; C:\Users\erhan\github\mcu\cc3200_c_pure\GPIO\0-sdkLayer\src
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: GPIO.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkConfigDefines: CC3200_ES_1_2_1=0
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\TexasInstruments\cc3200.icf
  ILINK.IlinkAdditionalLibs: C:\Users\erhan\github\mcu\cc3200_c_pure\PRCM\0-sdkLayer\inc\driverlib.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: main.c
  group 0-sdkLayer/inc
    0-sdkLayer/inc/: hw_gpio.h hw_memmap.h hw_prcm.h hw_types.h util.h
  group 0-sdkLayer/src
    0-sdkLayer/src/: hw_gpio.c hw_prcm.c util.c
